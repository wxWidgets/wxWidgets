/////////////////////////////////////////////////////////////////////////////
// Name:        src/retro68/app.cpp
// Purpose:     wxApp implementation for classic Mac OS
// Created:     2026-11-12
// Copyright:   (c) 2026 wxWidgets development team
// Licence:     wxWindows licence
/////////////////////////////////////////////////////////////////////////////

// For compilers that support precompilation, includes "wx.h".
#include "wx/wxprec.h"

#include "wx/app.h"

#ifndef WX_PRECOMP
    #include "wx/log.h"
    #include "wx/toplevel.h"
#endif

#include "wx/evtloop.h"

#include "wx/retro68/private/qd.h"

// Implemented in src/retro68/menu.cpp.
extern void wxMacSetupMenuBar();

// ============================================================================
// Toolbox initialization and Apple events handling
// ============================================================================

namespace
{

bool gs_toolboxInitialized = false;

#if !TARGET_API_MAC_CARBON
// Amount by which the stack is increased, can be predefined to override it.
#ifndef wxRETRO68_EXTRA_STACK_SIZE
    #define wxRETRO68_EXTRA_STACK_SIZE (512*1024)
#endif
#endif // !TARGET_API_MAC_CARBON

void InitToolbox()
{
    if ( gs_toolboxInitialized )
        return;

    gs_toolboxInitialized = true;

#if !TARGET_API_MAC_CARBON
    // The default stack size (8KB to 32KB depending on the machine) is much
    // too small for wxWidgets, so increase it before expanding the heap.
    // Notice that this may fail if the heap has already grown too much, but
    // there is nothing we can do about it then.
#ifdef __m68k__
    Ptr limit = LMGetApplLimit();
#else
    Ptr limit = GetApplLimit();
#endif
    SetApplLimit(limit - wxRETRO68_EXTRA_STACK_SIZE);

    // Make the application heap as big as possible and allocate more master
    // pointers to reduce heap fragmentation.
    MaxApplZone();
    for ( int n = 0; n < 8; n++ )
        MoreMasters();

    InitGraf(&qd.thePort);
    InitFonts();
    InitWindows();
    InitMenus();
    TEInit();
    InitDialogs(nullptr);
#endif // !TARGET_API_MAC_CARBON

    InitCursor();

    FlushEvents(everyEvent, 0);

    // We want to get key up events too, they're not generated by default.
    wxMacSetEventMask(everyEvent);
}

// Close all top level windows, return false if any of them refused to close.
bool CloseAllWindows()
{
    // Make a copy of the list as it is modified when windows are closed.
    wxWindowList windows;
    for ( wxWindow* win : wxTopLevelWindows )
        windows.push_back(win);

    for ( wxWindow* win : windows )
    {
        if ( !win->IsShown() )
            continue;

        if ( !win->Close() )
            return false;
    }

    return true;
}

pascal OSErr HandleQuitApplication(const AppleEvent* WXUNUSED(event),
                                   AppleEvent* WXUNUSED(reply),
                                   int32_t WXUNUSED(refcon))
{
    if ( !CloseAllWindows() )
        return userCanceledErr;

    if ( wxTheApp )
        wxTheApp->ExitMainLoop();

    return noErr;
}

pascal OSErr HandleOpenApplication(const AppleEvent* WXUNUSED(event),
                                   AppleEvent* WXUNUSED(reply),
                                   int32_t WXUNUSED(refcon))
{
    return noErr;
}

// Get the list of files from the event, return false if there are none.
bool GetFilesFromEvent(const AppleEvent* event, wxArrayString& files)
{
    AEDescList docList;
    if ( AEGetParamDesc(const_cast<AppleEvent*>(event), keyDirectObject,
                        typeAEList, &docList) != noErr )
    {
        return false;
    }

    int32_t count = 0;
    AECountItems(&docList, &count);

    for ( int32_t i = 1; i <= count; i++ )
    {
        FSSpec spec;
        AEKeyword keyword;
        DescType type;
        Size size;
        if ( AEGetNthPtr(&docList, i, typeFSS, &keyword, &type,
                         reinterpret_cast<Ptr>(&spec), sizeof(spec),
                         &size) == noErr )
        {
            const wxString path = wxMacFSSpecToPath(spec);
            if ( !path.empty() )
                files.push_back(path);
        }
    }

    AEDisposeDesc(&docList);

    return !files.empty();
}

pascal OSErr HandleOpenDocuments(const AppleEvent* event,
                                 AppleEvent* WXUNUSED(reply),
                                 int32_t WXUNUSED(refcon))
{
    wxArrayString files;
    if ( !GetFilesFromEvent(event, files) )
        return errAEEventNotHandled;

    if ( wxTheApp )
        wxTheApp->MacOpenFiles(files);

    return noErr;
}

pascal OSErr HandlePrintDocuments(const AppleEvent* event,
                                  AppleEvent* WXUNUSED(reply),
                                  int32_t WXUNUSED(refcon))
{
    wxArrayString files;
    if ( !GetFilesFromEvent(event, files) )
        return errAEEventNotHandled;

    if ( wxTheApp )
    {
        for ( const wxString& file : files )
            wxTheApp->MacPrintFile(file);
    }

    return noErr;
}

void InstallAppleEventHandlers()
{
    // Apple events are available since System 7.
    if ( !wxMacGestalt(gestaltAppleEventsAttr) )
        return;

    AEInstallEventHandler(kCoreEventClass, kAEQuitApplication,
                          NewAEEventHandlerUPP(HandleQuitApplication), 0, false);
    AEInstallEventHandler(kCoreEventClass, kAEOpenApplication,
                          NewAEEventHandlerUPP(HandleOpenApplication), 0, false);
    AEInstallEventHandler(kCoreEventClass, kAEOpenDocuments,
                          NewAEEventHandlerUPP(HandleOpenDocuments), 0, false);
    AEInstallEventHandler(kCoreEventClass, kAEPrintDocuments,
                          NewAEEventHandlerUPP(HandlePrintDocuments), 0, false);
}

} // anonymous namespace

// Called from the native "Quit" menu item.
void wxMacQuitApplication()
{
    HandleQuitApplication(nullptr, nullptr, 0);
}

//-----------------------------------------------------------------------------
// wxApp initialization
//-----------------------------------------------------------------------------

wxIMPLEMENT_DYNAMIC_CLASS(wxApp, wxEvtHandler);

wxApp::wxApp()
{
    m_isInForeground = true;

    WXAppConstructed();
}

wxApp::~wxApp()
{
}

bool wxApp::Initialize(int& argc, wxChar **argv)
{
    InitToolbox();

    if ( !wxAppBase::Initialize(argc, argv) )
        return false;

    InstallAppleEventHandlers();

    wxMacSetupMenuBar();

    return true;
}

void wxApp::CleanUp()
{
    wxAppBase::CleanUp();
}

void wxApp::WakeUpIdle()
{
    wxEventLoopBase * const loop = wxEventLoop::GetActive();
    if ( loop )
        loop->WakeUp();
}

//-----------------------------------------------------------------------------
// Mac-specific events
//-----------------------------------------------------------------------------

void wxApp::MacOpenFiles(const wxArrayString& fileNames)
{
    for ( const wxString& fileName : fileNames )
        MacOpenFile(fileName);
}

void wxApp::MacOpenFile(const wxString& WXUNUSED(fileName))
{
}

void wxApp::MacPrintFile(const wxString& WXUNUSED(fileName))
{
}

void wxApp::MacNewFile()
{
}

void wxApp::MacReopenApp()
{
    wxWindow* const top = GetTopWindow();
    if ( top )
    {
        top->Show();
        top->Raise();
    }
}
